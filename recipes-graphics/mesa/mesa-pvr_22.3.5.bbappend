COMPATIBLE_MACHINE:ti-am335x = "ti-am335x"
ALLOW_EMPTY:${PN}:ti-am335x = "1"
RRECOMMENDS:mesa-megadriver:append:class-target:ti-am335x = " ti-sgx-ddk-km"
