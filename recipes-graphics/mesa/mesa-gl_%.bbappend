PROVIDES_remove_ti-am335x = " glamor"
PACKAGECONFIG_remove_ti-am335x = " glamor"
PACKAGES_remove_ti-am335x = " libgbm libgbm-dev"
