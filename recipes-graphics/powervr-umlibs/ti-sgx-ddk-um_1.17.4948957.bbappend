COMPATIBLE_MACHINE:ti-am335x = "ti-am335x"
TARGET_PRODUCT:ti-am335x = "ti335x_linux"

