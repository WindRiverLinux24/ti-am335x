OPENGL_PKGCONFIGS_remove_ti-am335x = " glamor"
