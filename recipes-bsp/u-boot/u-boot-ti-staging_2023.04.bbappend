COMPATIBLE_MACHINE:ti-am335x = "ti-am335x"

SRCREV:ti-am335x = "d74d0993e2456e7a1d7c7d2af816f3dc5e54bf17"
