COMPATIBLE_MACHINE:ti-am335x = "ti-am335x"
