#
# Copyright (C) 2018 Wind River Systems, Inc.

require linux-yocto-ti-am335x.inc
KBRANCH_ti-am335x  = "standard/ti-am335x"
