#
# Copyright (C) 2017 Wind River Systems, Inc.
#

require linux-windriver-ti-am335x.inc
