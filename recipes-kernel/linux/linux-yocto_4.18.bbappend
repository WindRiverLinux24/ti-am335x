require linux-yocto-ti-am335x.inc

KBRANCH_ti-am335x  = "v4.18/standard/ti-am335x"
