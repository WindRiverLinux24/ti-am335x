require linux-yocto-ti-am335x.inc

KBRANCH:ti-am335x = "v6.6/standard/preempt-rt/ti-sdk-6.6/ti-soc"

