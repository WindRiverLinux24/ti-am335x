require linux-yocto-ti-am335x.inc

KBRANCH:ti-am335x  = "v6.1/standard/ti-sdk-6.1/ti-j7xxx"

