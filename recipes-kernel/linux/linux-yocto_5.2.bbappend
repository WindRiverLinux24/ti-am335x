require linux-yocto-ti-am335x.inc

KBRANCH_ti-am335x  = "v5.2/standard/base"

LINUX_VERSION_ti-am335x ?= "5.2.x"
